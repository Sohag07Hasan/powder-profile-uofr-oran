options:
  parameters:
    generate_options: qt_gui
    id: two_ue_two_gnb
    output_language: python
    title: Intra Handover Flowgraph
  states: {}

blocks:
- name: cell_gain0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '1'
  states: {}
- name: cell_gain1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain0
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2008
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:3008
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:3009
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2009
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:3000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:3010
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_1
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2010
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_throttle2_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_throttle2_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_throttle2_0_0_1, '0']
- [blocks_throttle2_0_0, '0', zeromq_rep_sink_0, '0']
- [blocks_throttle2_0_0_0, '0', zeromq_rep_sink_0_0, '0']
- [blocks_throttle2_0_0_0_0, '0', zeromq_rep_sink_0_0_0, '0']
- [blocks_throttle2_0_0_1, '0', zeromq_rep_sink_0_1, '0']
- [zeromq_req_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_req_source_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [zeromq_req_source_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [zeromq_req_source_0_1, '0', blocks_multiply_const_vxx_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
