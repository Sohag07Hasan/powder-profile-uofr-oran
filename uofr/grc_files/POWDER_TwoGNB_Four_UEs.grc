options:
  parameters:
    generate_options: qt_gui
    id: twoGNBfourUE
    output_language: python
    title: Multi UE Flowgraph
  states: {}

blocks:
- name: cell_gain0
  id: variable_qtgui_range
  parameters:
    start: min_gain
    step: '0.0001'
    stop: max_gain
    value: '0.050'
  states: {}
- name: cell_gain1
  id: variable_qtgui_range
  parameters:
    start: min_gain
    step: '0.0001'
    stop: max_gain
    value: '0.080'
  states: {}
- name: cell_gain2
  id: variable_qtgui_range
  parameters:
    start: min_gain
    step: '0.0001'
    stop: max_gain
    value: '0.050'
  states: {}
- name: cell_gain3
  id: variable_qtgui_range
  parameters:
    start: min_gain
    step: '0.0001'
    stop: max_gain
    value: '0.080'
  states: {}
- name: max_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: min_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain3
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain3
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain2
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: eNB1 Rx
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: eNB1 Tx
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: eNB2 Tx
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: eNB2 Rx
  states: {}
- name: note_0_0_0_1
  id: note
  parameters:
    note: UE2 Tx
  states: {}
- name: note_0_0_0_1_0
  id: note
  parameters:
    note: UE1 Rx
  states: {}
- name: note_0_0_0_1_0_0
  id: note
  parameters:
    note: UE1 Tx
  states: {}
- name: note_0_0_0_1_0_0_0
  id: note
  parameters:
    note: UE3 Tx
  states: {}
- name: note_0_0_0_1_0_1
  id: note
  parameters:
    note: UE3 Rx
  states: {}
- name: note_0_0_0_1_1
  id: note
  parameters:
    note: UE2 Rx
  states: {}
- name: note_0_0_0_1_1_0
  id: note
  parameters:
    note: UE4 Rx
  states: {}
- name: note_0_0_0_1_2
  id: note
  parameters:
    note: UE4 Tx
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2009
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:3009
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2008
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2006
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:3006
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:3008
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2010
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2007
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:3007
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_1
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:3010
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:3000
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_add_xx_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', zeromq_rep_sink_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', zeromq_rep_sink_1_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', zeromq_rep_sink_1, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', zeromq_rep_sink_1_1, '0']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_xx_0_0, '0']
- [blocks_throttle2_0, '0', zeromq_rep_sink_0, '0']
- [blocks_throttle2_0_0, '0', zeromq_rep_sink_0_0, '0']
- [blocks_throttle2_1, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_throttle2_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_throttle2_1_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_throttle2_1_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [zeromq_req_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_req_source_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [zeromq_req_source_0_0_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [zeromq_req_source_0_1, '0', blocks_multiply_const_vxx_0_2, '0']
- [zeromq_req_source_1, '0', blocks_throttle2_1, '0']
- [zeromq_req_source_1_0, '0', blocks_throttle2_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
